# IAR project gpio_demo.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DX256xxx10 Freescale MK60DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\..\src\common; ..\..\src\cpu; ..\..\src\drivers; ..\..\src\drivers\gpio; ..\..\src\drivers\wdog; ..\..\src\drivers\mcg; ..\..\src\drivers\uart; ..\..\src\drivers\lptmr; ..\..\src\drivers\fun; ..\..\src\drivers\led; ..\..\src\drivers\i2c; ..\..\src\drivers\MMA845x; ..\..\src\drivers\motor; ..\..\src\drivers\pit; ..\..\src\drivers\steer; ..\..\src\drivers\ftm; ..\..\src\drivers\DIPswitch; ..\..\src\drivers\dma; ..\..\src\platforms; ..\..\src\projects; ..\..\src\projects\gpio_demo
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gpio_demo.srec
  ILINK.IlinkOutputFile: gpio_demo.out
  ILINK.IlinkIcfFile: ..\..\Project_Settings\Link\Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\; ..\..\src\common; ..\..\src\cpu; ..\..\src\drivers; ..\..\src\drivers\gpio; ..\..\src\drivers\flash; ..\..\src\drivers\olcd; ..\..\src\drivers\diskio; ..\..\src\drivers\iospi; ..\..\src\drivers\wdog; ..\..\src\drivers\mcg; ..\..\src\drivers\flash; ..\..\src\drivers\uart; ..\..\src\drivers\lptmr; ..\..\src\drivers\LED; ..\..\src\drivers\fun; ..\..\src\drivers\FTM; ..\..\src\drivers\pit; ..\..\src\drivers\DIPswitch; ..\..\src\drivers\steer; ..\..\src\drivers\motor; ..\..\src\drivers\laser; ..\..\src\drivers\i2c; ..\..\src\drivers\ADdevice; ..\..\src\drivers\adc; ..\..\src\drivers\serial_digtal_scope; ..\..\src\drivers\MMA845x; ..\..\src\drivers\exti; ..\..\src\drivers\dma; ..\..\src\platforms; ..\..\src\projects; ..\..\src\projects\gpio_demo; ..\..\src\drivers\MPU6050; ..\..\src\drivers\steer
  ILINK.IlinkIcfFile: ..\..\Project_Settings\Link\Pflash.icf
  group app
    ../../src/projects/gpio_demo/: control.c isr.c main.c
    ./: global.c
  group common
    ../../src/common/: assert.c startup.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/adc/: adc.c
    ../../src/drivers/ADdevice/: ADdevice.c
    ../../src/drivers/diskio/: diskio.c Sdhc.c
    ../../src/drivers/dma/: dma.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/Flash/: flash.c
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/fun/: fun.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/i2c/: i2c.c ioi2c.c
    ../../src/drivers/iospi/: iospi.c
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/MMA845x/: MMA845x.c
    ../../src/drivers/motor/: motor.c
    ../../src/drivers/MPU6050/: MPU6050.c
    ../../src/drivers/olcd/: olcd.c
    ../../src/drivers/serial_digtal_scope/: outputdata.c
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/steer/: steer.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/common/: common.h
    ../../src/drivers/diskio/: diskio.h Sdhc.h
    ../../src/drivers/: drivers_cfg.h
    ../../../../../../ARROWS 11-24(开环2.2m/ARROWS 11-24(开环2.2m/src/drivers/flash/: flash.h
    ../../src/drivers/fun/: fun.h
    ../../src/drivers/i2c/: i2c.h
    ../../src/projects/gpio_demo/: include.h isr.h
    ../../src/drivers/iospi/: iospi.h
    ../../src/platforms/: k60_bupt.h
    ../../src/cpu/: MK60DZ10.h
    ../../src/drivers/MMA845x/: MMA845x.h
    ../../src/drivers/MPU6050/: MPU6050.h
    ../../src/drivers/olcd/: olcd.h
  group Link
    ../../Project_Settings/Link/: Pflash.icf Ram.icf
