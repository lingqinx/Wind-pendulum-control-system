# IAR project SX_demo.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DX256xxx10 Freescale MK60DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\..\src\common; ..\..\src\cpu; ..\..\src\drivers; ..\..\src\drivers\gpio; ..\..\src\drivers\wdog; ..\..\src\drivers\mcg; ..\..\src\drivers\uart; ..\..\src\drivers\lptmr; ..\..\src\drivers\LED; ..\..\src\drivers\fun; ..\..\src\drivers\FTM; ..\..\src\drivers\pit; ..\..\src\drivers\DIPswitch; ..\..\src\drivers\steer; ..\..\src\drivers\ccd; ..\..\src\drivers\dma; ..\..\src\drivers\motor; ..\..\src\platforms; ..\..\src\projects; ..\..\src\projects\SX_demo
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gpio_demo.srec
  ILINK.IlinkOutputFile: gpio_demo.out
  ILINK.IlinkIcfFile: ..\..\Project_Settings\Link\Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: SX_demo.srec
  ILINK.IlinkIcfFile: ..\..\Project_Settings\Link\Pflash.icf
  group app
    ../../src/projects/SX_demo/: global.c isr.c main.c
  group common
    ../../src/common/: assert.c startup.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/ccd/: ccd.c
    ../../src/drivers/DIPswitch/: DIPswitch.c
    ../../src/drivers/dma/: dma.c
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/fun/: fun.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/motor/: motor.c
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/steer/: steer.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/common/: common.h
    ../../src/projects/SX_demo/: drivers_cfg.h global.h include.h isr.h
    ../../src/platforms/: k60_bupt.h
    ../../src/cpu/: MK60DZ10.h
  group Link
    ../../Project_Settings/Link/: Pflash.icf Ram.icf
